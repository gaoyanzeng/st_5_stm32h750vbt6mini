# Keil uVision project NewDevice.uvprojx, settings and files
target Cortex-M (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750_V1 +hex
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM,USE_HAL_DRIVER, STM32H743xx
  c include: ..\Core\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Flash;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\CMSIS\Include;..\Drivers\Hare\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../Flash/: FlashPrg.c
  group Device Description
    ../Flash/: FlashDev.c
  group Drivers/User
    ../Drivers/Hare/Src/: qspi_w25q64.c SystemConfig.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c stm32h7xx_hal_qspi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
target ARM7_ARM9 (ARM-ADS)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: ROM 0x30000000 size 0x48000
  memory RVCT7: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
